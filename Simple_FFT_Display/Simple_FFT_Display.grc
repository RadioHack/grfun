<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>Test GR #1</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>107700000</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>frequency</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>0</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>throttle_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>throttle_rate</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>throttle_rate</value></param>
<param><key>baseband_freq</key><value>frequency</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>720, 320</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>throttle_rate</value></param>
<param><key>baseband_freq</key><value>frequency</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>30</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>13490</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>720, 120</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
